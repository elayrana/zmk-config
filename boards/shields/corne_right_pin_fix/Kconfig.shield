## boards/shields/corne_right_pin_fix/Kconfig.shield
```kconfig
config SHIELD_CORNE_RIGHT_PIN_FIX
    def_bool $(shields_list_contains,corne_right_pin_fix)
```
